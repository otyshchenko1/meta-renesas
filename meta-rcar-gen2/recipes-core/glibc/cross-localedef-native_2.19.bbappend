# make compilation with GCC 5 possible
CFLAGS += " -fgnu89-inline"

