#Due to the gitorious.org shutdown linux-can decided to move to GitHub
SRC_URI = "git://github.com/linux-can/can-utils.git;protocol=git;branch=master"
SRCREV = "cda61171f1f559dbb3b25c9fede2cc2a85c7cd0d"
