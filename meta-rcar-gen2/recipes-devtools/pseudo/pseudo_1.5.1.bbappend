FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-strlen-result-cannot-be-static.patch"
