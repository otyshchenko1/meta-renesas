require gdb-linaro.inc